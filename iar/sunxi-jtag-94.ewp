# IAR project sunxi-jtag-94.ewp, settings and files
configuration V3s-dram-init (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: SOC_ID_V3S
  ICCARM.IExtraOptions: --diag_suppress Pe068; --diag_suppress Pe177; --diag_suppress Pe111; --diag_suppress Pe550; --diag_suppress Pe174; --diag_suppress Pe381; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\src\mock\; ..\u-boot\include\; ..\u-boot\arch\arm\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sun8i-v3s-dram-init.hex
  ILINK.IlinkOutputFile: sun8i-v3s-dram-init.out
  ILINK.IlinkIcfFile: sunxi.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration H3-dram-init (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SOC_ID_H3
  OBJCOPY.OOCOutputFile: sun8i-h3-dram-init.hex
  ILINK.IlinkOutputFile: sun8i-h3-dram-init.out
configuration V3s-dram-app (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOC_ID_V3S; DRAM_APP
  ICCARM.IExtraOptions: --diag_suppress Pe068; --diag_suppress Pe177; --diag_suppress Pe111; --diag_suppress Pe550; --diag_suppress Pe174; --diag_suppress Pe381
  OBJCOPY.OOCOutputFile: sunxi-jtag.hex
  ILINK.IlinkOutputFile: V3s-dram-app.out
  ILINK.IlinkConfigDefines: DDR=1
configuration H3-dram-app (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SOC_ID_H3; DRAM_APP
  ICCARM.IExtraOptions: as above
  OBJCOPY.OOCOutputFile: sunxi-jtag.hex
  ILINK.IlinkOutputFile: V3s-dram-app.out
  ILINK.IlinkConfigDefines: DDR=1
  group (top)
    ../../../../../../../../../../Program Files/IAR Systems/Embedded Workbench 9.2_2/arm/src/lib/arm/: cstartup_v8.s
    ../src/: main_app.c main_init.c sunxi_jtag.h write.c
  group assets/ddf
    ddf/: H3.ddf V3s.ddf
  group assets/icf
    ./: sunxi-dram-app.icf sunxi-dram-init.icf
  group assets/macro
    ./: sunxi.mac
  group u-boot/arch/arm/cpu/armv7
    ../u-boot/arch/arm/cpu/armv7/: syslib.c
  group u-boot/arch/arm/cpu/armv7/sunxi
    ../u-boot/arch/arm/cpu/armv7/sunxi/: sram.c tzpc.c
  group u-boot/arch/arm/mach-sunxi
    ../u-boot/arch/arm/mach-sunxi/: board.c clock.c clock_sun6i.c cpu_info.c dram_helpers.c dram_sunxi_dw.c timer.c
  group u-boot/arch/arm/mach-sunxi/dram_timings
    ../u-boot/arch/arm/mach-sunxi/dram_timings/: ddr2_v3s.c ddr3_1333.c lpddr3_stock.c
  group u-boot/board/sunxi
    ../u-boot/board/sunxi/: board.c
  group u-boot/drivers/gpio
    ../src/: sunxi_gpio.c
  group u-boot/drivers/serial
    ../u-boot/drivers/serial/: ns16550.c serial.c serial_ns16550.c
